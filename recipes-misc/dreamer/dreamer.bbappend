do_install_append() {
    echo "Sweet dreams!" >> ${D}${sysconfdir}/dreamer.conf
}

